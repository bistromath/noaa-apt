options:
  parameters:
    author: nick
    generate_options: qt_gui
    id: wx
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: audio_bw
  id: variable_qtgui_range
  parameters:
    gui_hint: (2,2,1,1)
    label: baseband audio bw
    orient: Qt.Horizontal
    start: '300'
    step: '10'
    stop: '4000'
    value: '1500'
  states: {}
- name: decim
  id: variable
  parameters:
    value: '18'
  states: {}
- name: doppler_freq
  id: variable
  parameters:
    value: rf_freq*1e6
  states: {}
- name: doppler_label
  id: variable_qtgui_label
  parameters:
    gui_hint: (3,2,1,1)
    label: Doppler offset
    type: string
    value: '"%dHz" % offset_freq'
  states: {}
- name: lo_freq
  id: variable
  parameters:
    value: 10.7e6
  states: {}
- name: max_resid_freq_hz
  id: variable
  parameters:
    value: '500'
  states: {}
- name: offset_freq
  id: variable
  parameters:
    value: rf_freq*1e6-doppler_freq
  states: {}
- name: out_rate
  id: variable
  parameters:
    value: samp_rate/decim
  states: {}
- name: rf_freq
  id: variable
  parameters:
    value: 137.9125e6
  states: {state: disabled}
- name: rf_freq
  id: variable_qtgui_entry
  parameters:
    gui_hint: (4,2,1,1)
    label: Frequency (MHz)
    type: real
    value: '137.9125'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 768e3
  states: {}
- name: vol
  id: variable_qtgui_range
  parameters:
    gui_hint: (1,2,1,1)
    label: volume
    orient: Qt.Horizontal
    start: '0'
    step: '0.0001'
    stop: '0.1'
    value: '0.02'
  states: {}
- name: analog_pll_carriertracking_cc_0
  id: analog_pll_carriertracking_cc
  parameters:
    max_freq: math.pi*max_resid_freq_hz/out_rate
    min_freq: '-math.pi*max_resid_freq_hz/out_rate'
    w: '0.05'
  states: {}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: samp_rate/(2*math.pi*34000/8.0)
  states: {}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /tmp/noaa18_wat.dat
    type: complex
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/nick/dev/apt/noaa19_5.dat
    repeat: 'True'
    type: complex
  states: {state: disabled}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_multiply_const_xx_0
  id: blocks_multiply_const_xx
  parameters:
    const: vol
    type: float
  states: {}
- name: blocks_rotator_cc_0
  id: blocks_rotator_cc
  parameters:
    phase_inc: 2*math.pi*offset_freq/samp_rate
  states: {}
- name: blocks_rotator_cc_0_0
  id: blocks_rotator_cc
  parameters:
    phase_inc: '-2*math.pi*2400/out_rate'
  states: {}
- name: filter_fft_low_pass_filter_0
  id: filter_fft_low_pass_filter
  parameters:
    cutoff_freq: '17000'
    decim: decim
    gain: '1'
    samp_rate: samp_rate
    type: ccc
    width: '1000'
    win: firdes.WIN_HAMMING
  states: {}
- name: filter_fft_low_pass_filter_1
  id: filter_fft_low_pass_filter
  parameters:
    cutoff_freq: audio_bw
    decim: '1'
    gain: '1'
    samp_rate: out_rate
    type: ccf
    width: audio_bw/10
    win: firdes.WIN_HAMMING
  states: {}
- name: gpredict_doppler_0
  id: gpredict_doppler
  parameters:
    freqvar: doppler_freq
    host: localhost
    port: '4532'
    verbose: 'False'
  states: {}
- name: hilbert_fc_0
  id: hilbert_fc
  parameters:
    num_taps: '65'
    win: firdes.WIN_HAMMING
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    args: '"airspyhf=0"'
    bb_gain0: '20'
    freq0: lo_freq
    gain0: '10'
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    alpha1: '1'
    average: '0.05'
    bw: samp_rate
    ctrlpanel: 'True'
    fc: rf_freq
    fftsize: '4096'
    gui_hint: (0,2,1,1)
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: out_rate
    fc: '0'
    fftsize: '4096'
    type: float
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {state: disabled}
- name: qtgui_time_raster_sink_x_0
  id: qtgui_time_raster_sink_x
  parameters:
    color1: '1'
    gui_hint: (0,0,4,2)
    mult: '[-1]'
    ncols: int(out_rate/2)
    nrows: 60*15
    offset: '[1]'
    samp_rate: out_rate
    type: float
    update_time: '0.25'
    zmin: '0'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: (0,2,1,1)
    size: '1024'
    srate: samp_rate
    tr_level: '0.01'
    tr_mode: qtgui.TRIG_MODE_AUTO
    type: complex
  states: {state: disabled}

connections:
- [analog_pll_carriertracking_cc_0, '0', analog_quadrature_demod_cf_0, '0']
- [analog_quadrature_demod_cf_0, '0', hilbert_fc_0, '0']
- [blocks_complex_to_float_0, '0', blocks_float_to_complex_0, '1']
- [blocks_complex_to_float_0, '1', blocks_float_to_complex_0, '0']
- [blocks_complex_to_mag_0, '0', blocks_multiply_const_xx_0, '0']
- [blocks_file_source_0, '0', analog_pll_carriertracking_cc_0, '0']
- [blocks_float_to_complex_0, '0', blocks_rotator_cc_0, '0']
- [blocks_multiply_const_xx_0, '0', qtgui_time_raster_sink_x_0, '0']
- [blocks_rotator_cc_0, '0', filter_fft_low_pass_filter_0, '0']
- [blocks_rotator_cc_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_rotator_cc_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_rotator_cc_0_0, '0', filter_fft_low_pass_filter_1, '0']
- [filter_fft_low_pass_filter_0, '0', analog_pll_carriertracking_cc_0, '0']
- [filter_fft_low_pass_filter_0, '0', blocks_file_sink_0, '0']
- [filter_fft_low_pass_filter_1, '0', blocks_complex_to_mag_0, '0']
- [hilbert_fc_0, '0', blocks_rotator_cc_0_0, '0']
- [osmosdr_source_0, '0', blocks_complex_to_float_0, '0']

metadata:
  file_format: 1
